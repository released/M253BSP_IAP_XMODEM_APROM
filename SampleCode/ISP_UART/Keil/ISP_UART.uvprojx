# Keil uVision project ISP_UART.uvprojx, settings and files
target Template (6120000::V6.12::.\ARMCLANG)
  device: M253LE3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.20
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: ISP_UART +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\Device\Nuvoton\M253\Include;..\..\ISP_UART
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3ff0
  memory RVCT10: RAM 0x20003ff0 size 0x10
  link misc: --map --first='startup_M253.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M253/Source/: system_M253.c
    ../../../Library/Device/Nuvoton/M253/Source/ARM/: startup_M253.s
  group Library
    ../../../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c timer.c gpio.c fmc.c crc.c
  group User
    ../: main.c misc_config.c fmc_user.c isp_user.c targetdev.c uart_transfer.c xmodem.c
software components: CMSIS:CORE 5.2.0
